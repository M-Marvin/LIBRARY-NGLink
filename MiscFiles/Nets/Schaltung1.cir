** Schaltung1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: marvi
* Thu, Feb 17, 2022 22:49:43
*

*## Multisim Component X1 ##*
xX1 X1_OPEN_X1 X1_OPEN_X2 CRYSTAL_HC-49/U_1.5MHZ__CRYSTAL__1

.SUBCKT CRYSTAL_HC-49/U_1.5MHZ__CRYSTAL__1 1 2
* EWB Version 4 - CRYSTAL Model
* LS= 1.6 CS= 7e-015 RS= 500 CO= 4e-012
    LS   1  3 1.6
    CS   3  4 7e-015
    RS   4  2 500
    CO   1  2 4e-012
.ENDS
