** Oszillator Test **
*
* NI Multisim to SPICE Netlist Export
* Generated by: marvi
* Thu, Feb 17, 2022 15:38:27
*

*## Multisim Component C5 ##*
cC5 9 11 1e-06

*## Multisim Component C4 ##*
cC4 7 10 1e-06

*## Multisim Component R8 ##*
rR8 10 9 200000 vresR8
.model vresR8 r(  )

*## Multisim Component R7 ##*
rR7 5 9 21000 vresR7
.model vresR7 r(  )

*## Multisim Component Q4 ##*
qQ4 9 10 0 2N2222A__BJT_NPN__1

*## Multisim Component R6 ##*
rR6 8 7 200000 vresR6
.model vresR6 r(  )

*## Multisim Component C3 ##*
cC3 3 8 1e-06

*## Multisim Component R5 ##*
rR5 5 7 20000 vresR5
.model vresR5 r(  )

*## Multisim Component Q3 ##*
qQ3 7 8 0 2N2222A__BJT_NPN__1

*## Multisim Instrument XSC1 ##*

*## Multisim Component R4 ##*
rR4 5 4 2000 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 5 2 2000 vresR3
.model vresR3 r(  )

*## Multisim Component Q2 ##*
qQ2 3 2 0 2N2222A__BJT_NPN__1

*## Multisim Component R2 ##*
rR2 5 3 200 vresR2
.model vresR2 r(  )

*## Multisim Component C2 ##*
cC2 4 3 8e-07

*## Multisim Component Q1 ##*
qQ1 1 4 0 2N2222A__BJT_NPN__1

*## Multisim Component R1 ##*
rR1 5 1 200 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 1 2 8e-07

*## Multisim Component V1 ##*
vV1 5 0 dc 5 ac 0 0
+           distof1 0 0
+           distof2 0 0

.MODEL 2N2222A__BJT_NPN__1 npn
+IS=2.04566e-13 BF=296.463 NF=1.09697 VAF=10
+IKF=0.0772534 ISE=1.45081e-13 NE=1.39296 BR=0.481975
+NR=1.16782 VAR=100 IKR=0.100004 ISC=1.00231e-13
+NC=1.98587 RB=3.99688 IRB=0.2 RBM=3.99688
+RE=0.0857267 RC=0.428633 XTB=0.1 XTI=1
+EG=1.05 CJE=1.09913e-11 VJE=0.99 MJE=0.23
+TF=2.96787e-10 XTF=9.22776 VTF=25.2257 ITF=0.0793144
+CJC=3.1941e-11 VJC=0.4 MJC=0.85 XCJC=0.901093
+FC=0.1 CJS=0 VJS=0.75 MJS=0.5
+TR=3.83883e-07 PTF=0 KF=0 AF=1
